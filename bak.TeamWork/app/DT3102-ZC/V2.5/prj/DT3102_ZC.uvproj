# Keil uVision project DT3102_ZC.uvproj, settings and files
target DT3102-ZC-2.5 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DT3102-ZC-V2-5 +hex
  AfterMake: D:\Keil\ARM\BIN40\fromelf.exe --bin -o ../Bin/DT3102-ZC-V2.5.bin Out/DT3102-ZC-V2-5.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\algorim\inc;..\gui\inc;..\main\inc;..\..\..\..\common\;..\..\..\..\emos\V1.2\driver;..\..\..\..\common\crc\v1.0.0;..\..\..\..\common\list\clist\V1.0.0;..\..\..\..\common\list\dlist\V1.0.0;..\..\..\..\common\list\slist\V1.0.0;..\..\..\..\common\queue\kfifo\V1.0.0;..\..\..\..\emos\V1.2\driver\ad\cs5532\V1.2.0\inc;..\..\..\..\emos\V1.2\driver\cbus\i2c\V1.2.0;..\..\..\..\emos\V1.2\driver\cbus\spi\V1.2.0;..\..\..\..\emos\V1.2\driver\crc\stm32f4xx\V1.2.0;..\..\..\..\emos\V1.2\driver\eeprom\f24clxx\V1.2.0;..\..\..\..\emos\V1.2\driver\flash\max25xx\V1.2.0;..\..\..\..\emos\V1.2\driver\io\V1.2.0;..\..\..\..\emos\V1.2\driver\keyboard\V1.2.0;..\..\..\..\emos\V1.2\driver\lcd\V1.2.0\inc;..\..\..\..\emos\V1.2\driver\mcu\CCM_Mem;..\..\..\..\emos\V1.2\driver\mcu\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\emos\V1.2\driver\mcu\CMSIS\Include;..\..\..\..\emos\V1.2\driver\mcu\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\..\..\emos\V1.2\driver\mcu\STM32F4xx_StdPeriph_Driver\;..\..\..\..\emos\V1.2\driver\mcu\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\emos\V1.2\driver\model\V1.2.0;..\..\..\..\emos\V1.2\driver\rtc\pcf8563\V1.2.0;..\..\..\..\emos\V1.2\driver\rtc\stm32f4xx\V1.2.0;..\..\..\..\emos\V1.2\driver\sound\beep\V1.2.0;..\..\..\..\emos\V1.2\driver\timer\V1.2.0\inc;..\..\..\..\emos\V1.2\driver\usart\V1.2.0\inc;..\..\..\..\emos\V1.2\driver\usb\v1.2.0;..\..\..\..\emos\V1.2\driver\usb\v1.2.0\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\emos\V1.2\driver\usb\v1.2.0\STM32_USB_HOST_Library\Core\inc;..\..\..\..\emos\V1.2\driver\usb\v1.2.0\STM32_USB_OTG_Driver\inc;..\..\..\..\emos\V1.2\driver\wachdog\v1.2.0;..\..\..\..\emos\V1.2\fs\fat_fs\inc;..\..\..\..\emos\V1.2\gui\V1.2.0\Inc;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\port\STM32F4x7\ucos;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\src\include;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\src\include\ipv4;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\src\include\lwip;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\port\STM32F4x7\;..\..\..\..\emos\V1.2\net\Lwip\lwip_v1.3.2\user;..\..\..\..\emos\V1.2\os\V1.2.2\OS_EXT;..\..\..\..\emos\V1.2\os\V1.2.2\OS_LIB;..\..\..\..\emos\V1.2\os\V1.2.2\uC-CPU\Source;..\..\..\..\emos\V1.2\os\V1.2.2\uC-CPU\ports;..\..\..\..\emos\V1.2\os\V1.2.2\uC-LIB\Source;..\..\..\..\emos\V1.2\os\V1.2.2\uC-LIB\Ports;..\..\..\..\emos\V1.2\os\V1.2.2\uCOS-II\Cfg;..\..\..\..\emos\V1.2\os\V1.2.2\uCOS-II\Ports;..\..\..\..\emos\V1.2\os\V1.2.2\uCOS-II\Source;..\..\..\..\pattern\SAS\V1.0.0\Module\inc;..\..\..\..\pattern\SAS\V1.0.0\parameter\inc;..\..\..\..\pattern\SAS\V1.0.0\Thread\inc;..\..\..\..\weight\V1.0.0\drv;..\..\..\..\weight\V1.0.0\Mode;..\..\..\..\weight\V1.0.0\Filter\fir;..\..\..\..\weight\V1.0.0\Standlize;..\..\..\..\weight\V1.0.0\Normalize;..\..\..\..\weight\V1.0.0\Normalize\linefit;..\..\..\..\weight\V1.0.0\ErrCheck;..\..\..\..\weight\V1.0.0\ZeroTrace;..\..\..\..\weight\V1.0.0\ZeroTrace\order3;..\..\..\..\weight\V1.0.0\Sample;..\..\..\..\weight\V1.0.0\flag
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App_Src
    ../main/src/: axle_business.c algorim_thread.c axletype_business.c app_timer.c barriergate_ctl.c business_thread.c car_business.c car_queue.c weight_param.c wet_algorim.c serial_protocol.c scszc_debug_info.c
  group App_Inc
    ../main/inc/: axle_business.h axletype_business.h app.h barriergate_ctl.h car_business.h car_queue.h weight_param.h wet_algorim.h scszc_debug_info.h serial_protocol.h
  group AppAlgorim_Src
    ../algorim/src/: AlexParser.c DyncAlexParserThree.c DyncSensorGetAxisAlgo.c DyncZerolize.c StaticProc.c Mode8AlexParser.c
  group AppAlgorim_Inc
    ../algorim/inc/: AlexParser.h DyncAlexParserThree.h DyncSensorGetAxisAlgo.h DyncZerolize.h StaticProc.h Mode8AlexParser.h
  group AppGui_Src
    ../gui/src/: ioctrl.c Common.c Ctr_Attr.c Ctr_DlgList.c Ctr_ListSelect.c Ctr_StatusBar.c Form_ADChannel.c Form_CalibrateAxleWeight.c Form_CalibrateInput.c Form_CalibrateSet.c Form_CalibrateWeight.c Form_CalibrateWeightMode1.c Form_CalibrateZero.c Form_DateSet.c Form_DetailQuery.c form_device_signal.c Form_InPortTest.c Form_Logo.c Form_Main.c Form_Main_Axle.c Form_Main_Veh.c Form_MainMenu.c Form_MeasureSet.c Form_MsgBox.c Form_NetSet.c Form_OutPortTest.c Form_OverLoadDetailQuery.c Form_OverloadQuery.c Form_OverLoadSet.c Form_PassWord.c Form_Query.c Form_Resource.c Form_SpeedMod.c Form_SystemSet.c Form_TimeDate.c Form_TimeSet.c Form_USB_updata.c Form_Version.c Form_VoiceSet.c Form_Warning.c Form_SubWeight.c
  group AppGui_Inc
    ../gui/inc/: Common.h Ctr_Attr.h Ctr_DlgList.h Ctr_ListSelect.h Ctr_StatusBar.h DataManager.h Form_ADChannel.h Form_Calibrate.h Form_CalibrateInput.h Form_CalibrateSet.h Form_CalibrateWeight.h Form_CalibrateWeightMode1.h Form_CalibrateZero.h Form_CarTypeMod.h Form_DateSet.h Form_DetailQuery.h Form_InPortTest.h Form_Logo.h Form_Main.h Form_Main_Axle.h Form_Main_Veh.h Form_MainMenu.h Form_MeasureSet.h Form_MsgBox.h Form_NetSet.h Form_OutPortTest.h Form_OverLoadDetailQuery.h Form_OverloadQuery.h Form_OverLoadSet.h Form_PassWord.h Form_Query.h Form_Resource.h Form_SpeedMod.h Form_SystemSet.h Form_TimeDate.h Form_TimeSet.h Form_USB_update.h Form_Version.h Form_VoiceSet.h Form_Warning.h ioctrl.h Matrix.h
  group AppPatternModule
    ../../../../pattern/SAS/V1.0.0/Module/src/: app_msg.c app_rtc.c app_beep.c data_store_module.c debug_info.c device_info.c LED.c overtime_queue.c sdk_serial.c softdog.c speed_check.c task_timer.c ymodem_update.c net_rmcpupdate_business.c RMCP.c
  group AppPatternThread
    ../../../../pattern/SAS/V1.0.0/Thread/src/: beep_thread.c datamanager_thread.c gui_thread.c key_thread.c net_business_thread.c serialrecv_thread.c task_def.c usb_thread.c
  group AppPatternParm
    ../../../../pattern/SAS/V1.0.0/parameter/src/: sys_config.c sys_param.c
  group AppPattern_Inc
    ../../../../pattern/SAS/V1.0.0/Module/inc/: app_msg.h app_rtc.h beep.h data_store_module.h debug_info.h device_info.h LED.h overtime_queue.h softdog.h speed_check.h task_timer.h
    ../../../../pattern/SAS/V1.0.0/parameter/inc/: sys_config.h sys_param.h
    ../../../../pattern/SAS/V1.0.0/Thread/inc/: beep_thread.h key_thread.h net_business_thread.h task_def.h
  group Algorim_Src
    ../../../../weight/V1.0.0/drv/: drvproc.c
    ../../../../weight/V1.0.0/Sample/: DigSample.c
    ../../../../weight/V1.0.0/ErrCheck/: ADCValueCheck.c
    ../../../../weight/V1.0.0/Standlize/: Standlize.c
    ../../../../weight/V1.0.0/Filter/fir/: FirFilter.c
    ../../../../weight/V1.0.0/ZeroTrace/order3/: ZeroTrace.c
    ../../../../weight/V1.0.0/flag/: StateCheck.c
    ../../../../weight/V1.0.0/Mode/: weight.c
    ../../../../weight/V1.0.0/Normalize/linefit/: LineFit.c
  group Algorim_Inc
    ../../../../weight/V1.0.0/drv/: drvproc.h
    ../../../../weight/V1.0.0/ErrCheck/: ADCValueCheck.h
    ../../../../weight/V1.0.0/Filter/fir/: FirFilter.h
    ../../../../weight/V1.0.0/flag/: StateCheck.h
    ../../../../weight/V1.0.0/Mode/: weight.h
    ../../../../weight/V1.0.0/Normalize/linefit/: LineFit.h
    ../../../../weight/V1.0.0/Sample/: DigSample.h
    ../../../../weight/V1.0.0/Standlize/: Standlize.h
    ../../../../weight/V1.0.0/ZeroTrace/order3/: ZeroTrace.h
  group AD&CS5532
    ../../../../emos/V1.2/driver/ad/cs5532/V1.2.0/src/: adjob.c spi_cs5532A.c spi_cs5532B.c
    ../../../../emos/V1.2/driver/ad/cs5532/V1.2.0/inc/: ADInterface.h adjob.h spi_cs5532A.h spi_cs5532B.h
  group Bsp_Src
    ../../../../pattern/SAS/V1.0.0/Module/src/: bsp_init.c
    ../../../../pattern/SAS/V1.0.0/Module/inc/: bsp_init.h
  group BootLoader
    ../../../../emos/V1.2/driver/mcu/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx_C2.s
  group Stm32HardCrc
    ../../../../emos/V1.2/driver/crc/stm32f4xx/V1.2.0/: stm32f4_crc.c stm32f4_crc.h
  group ccm_mem
    ../../../../emos/V1.2/driver/mcu/CCM_Mem/: ccm_mem.c ccm_mem.h
  group Common
    ../../../../common/queue/kfifo/V1.0.0/: kfifo.c kfifo.h
    ../../../../common/crc/v1.0.0/: crc.c crc.h
  group Flash
    ../../../../emos/V1.2/driver/flash/max25xx/V1.2.0/: mx251608d.c mx251608d.h
  group Fram
    ../../../../emos/V1.2/driver/eeprom/f24clxx/V1.2.0/: f24cl64.c f24cl64.h
  group GUI
    ../../../../emos/V1.2/gui/V1.2.0/Src/: Menu.c TextEdit.c Windows.c GDI.c
    ../../../../emos/V1.2/gui/V1.2.0/Inc/: GuiWindows.h Menu.h TextEdit.h Windows.h
  group IO
    ../../../../emos/V1.2/driver/io/V1.2.0/: io.h dt3102_io.c dt3102_io.h
  group I2C
    ../../../../emos/V1.2/driver/cbus/i2c/V1.2.0/: I2Cx.c I2Cx.h
  group KeyBoard
    ../../../../emos/V1.2/driver/keyboard/V1.2.0/: key_cfg.h keyboard.c keyboard.h
  group LCD
    ../../../../emos/V1.2/driver/lcd/V1.2.0/src/: LCD.c
  group Net
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/user/: LWIP_Impl.h LWIP_NetAddr.h eth_init.c netconf.c stm32f4x7_eth.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/port/STM32F4x7/ucos/: sys_arch.c ethernetif.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../emos/V1.2/net/Lwip/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
  group OS_Ext
    ../../../../emos/V1.2/os/V1.2.2/OS_EXT/: task_msg.c task_msg.h
  group OS_Lib
    ../../../../emos/V1.2/os/V1.2.2/OS_LIB/: includes.h
    ../../../../emos/V1.2/os/V1.2.2/uC-CPU/Source/: cpu_def.h
    ../../../../emos/V1.2/os/V1.2.2/uC-CPU/Ports/: cpu_a.asm cpu_c.c
    ../../../../emos/V1.2/os/V1.2.2/uCOS-II/Cfg/: sys_cfg.h
    ../../../../emos/V1.2/os/V1.2.2/uCOS-II/Custom/Src/: sys_app_hooks.c
    ../../../../emos/V1.2/os/V1.2.2/uCOS-II/Ports/: sys_cpu.h sys_cpu_a.asm sys_cpu_c.c sys_dbg.c
    ../../../../emos/V1.2/os/V1.2.2/uCOS-II/Source/: C2.h sys_core.c sys_flag.c sys_mbox.c sys_mem.c sys_mutex.c sys_q.c sys_sem.c sys_task.c sys_time.c sys_tmr.c
  group Pcf8563
    ../../../../emos/V1.2/driver/rtc/pcf8563/V1.2.0/: pcf8563.c pcf8563.h
  group Sys_Lib
    ../../../../emos/V1.2/driver/model/V1.2.0/: driver.c driver.h stm32f4xx_it.c system_init.c system_init.h
  group Stm32F4xx_lib
    ../../../../emos/V1.2/driver/mcu/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../../../emos/V1.2/driver/mcu/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group Spi
    ../../../../emos/V1.2/driver/cbus/spi/V1.2.0/: SPIx.c SPIx.h
  group Sound
    ../../../../emos/V1.2/driver/sound/beep/V1.2.0/: beep_init.c beep_init.h
  group Timer
    ../../../../emos/V1.2/driver/timer/V1.2.0/src/: timer2.c timer5.c timer6.c timer7.c
    ../../../../emos/V1.2/driver/timer/V1.2.0/inc/: timer2.h timer5.h timer6.h timer7.h
  group USB
    ../../../../emos/V1.2/driver/usb/v1.2.0/: Job_USB.c usb_bsp.c usbh_usr.c
    ../../../../emos/V1.2/driver/usb/v1.2.0/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
    ../../../../emos/V1.2/driver/usb/v1.2.0/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../../emos/V1.2/driver/usb/v1.2.0/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Usb_Fat32
    ../../../../emos/V1.2/fs/fat_fs/src/: fattime.c ff.c
    ../../../../emos/V1.2/fs/fat_fs/inc/: fattime.h ff.h
  group Usart
    ../../../../emos/V1.2/driver/usart/V1.2.0/src/: printf_init.c usart1.c usart6.c usart_timer.c
    ../../../../emos/V1.2/driver/usart/V1.2.0/inc/: usart1.h usart6.h usart_cfg.h usart_timer.h
  group WatchDog
    ../../../../emos/V1.2/driver/wachdog/v1.2.0/: dog_init.c dog_init.h watchdog_model.c watchdog_model.h
