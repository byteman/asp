# Keil uVision project BootLoader.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BootLoader +hex
  AfterMake: D:\Program Files\Keil\KeilArm\ARM\BIN40\fromelf.exe --bin -o ../Bin/BootLoader.bin Out/BootLoader.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\App\Inc;..\Bsp\HAL\Inc;..\Bsp\External\Inc;..\..\Stm32_Libraries\STM32F4xx_StdPeriph_Driver\Libraries\STM32F4xx_StdPeriph_Driver;..\..\Stm32_Libraries\STM32F4xx_StdPeriph_Driver\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Stm32_Libraries\STM32F4xx_StdPeriph_Driver\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App_Inc
    ../App/Inc/: main.h ConnectCfg.h RTC_Alarm.h
    ../Bsp/External/Inc/: ymodem_init.h Flash_bootloader_init.h
  group App_Src
    ../App/Src/: main.c ConnectCfg.c RTC_Alarm.c
    ../Bsp/External/Src/: ymodem_init.c Flash_bootloader_init.c
  group Bsp_Inc
    ../Bsp/HAL/Inc/: nvic_init.h crc_init.h tim6_init.h rtc_init.h usart1_init.h usart3_init.h usart6_init.h usart_cfg.h Flash_init.h
    ../Bsp/External/Inc/: power_init.h BootKey_init.h static_init.h printf_init.h
  group Bsp_Src
    ../Bsp/HAL/Src/: nvic_init.c crc_init.c tim6_init.c rtc_init.c usart1_init.c usart3_init.c usart6_init.c Flash_init.c
    ../Bsp/External/Src/: power_init.c BootKey_init.c static_init.c printf_init.c
  group CPU
    ../../Stm32_Libraries/STM32F4xx_StdPeriph_Driver/Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../../Stm32_Libraries/STM32F4xx_StdPeriph_Driver/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StartUp
    ../../Stm32_Libraries/STM32F4xx_StdPeriph_Driver/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx_C2.s
  group StdPeriph_Driver
    ../../Stm32_Libraries/STM32F4xx_StdPeriph_Driver/Libraries/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h
    ../../Stm32_Libraries/STM32F4xx_StdPeriph_Driver/: stm32f4xx_it.c
