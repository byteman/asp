# Keil uVision project emoslib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: emoslib (library)
  c flags: Optim=1 OneElfS=1
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\..\..\common\queue\kfifo\V1.0.0;..\include\driver\ad\cs5532\V1.2.0\inc;..\include\driver\cbus\i2c\V1.2.0;..\include\driver\cbus\spi\V1.2.0;..\include\driver\crc\stm32f4xx\V1.2.0;..\include\driver\eeprom\f24clxx\V1.2.0;..\include\driver\flash\max25xx\V1.2.0;..\include\driver\io\V1.2.0;..\include\driver\keyboard\V1.2.0;..\include\driver\lcd\V1.2.0\inc;..\include\driver\mcu\CMSIS\Device\ST\STM32F4xx\Include;..\include\driver\mcu\CMSIS\Include;..\include\driver\mcu\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\include\driver\mcu\STM32F4xx_StdPeriph_Driver\;..\include\driver\mcu\STM32F4xx_StdPeriph_Driver\inc;..\include\driver\model\V1.2.0;..\include\driver\rtc\pcf8563\V1.2.0;..\include\driver\rtc\stm32f4xx\V1.2.0;..\include\driver\sound\beep\V1.2.0;..\include\driver\timer\V1.2.0\inc;..\include\driver\usart\V1.2.0\inc;..\include\driver\usb\v1.2.0;..\include\driver\usb\v1.2.0\STM32_USB_HOST_Library\Class\MSC\inc;..\include\driver\usb\v1.2.0\STM32_USB_HOST_Library\Core\inc;..\include\driver\usb\v1.2.0\STM32_USB_OTG_Driver\inc;..\include\driver\wachdog\v1.2.0;..\include\fs\fat_fs\inc;..\include\gui\V1.2.0\Inc;..\include\net\Lwip\lwip_v1.3.2\port\STM32F4x7\ucos;..\include\net\Lwip\lwip_v1.3.2\src\include;..\include\net\Lwip\lwip_v1.3.2\src\include\ipv4;..\include\net\Lwip\lwip_v1.3.2\src\include\lwip;..\include\net\Lwip\lwip_v1.3.2\port\STM32F4x7\;..\include\net\Lwip\lwip_v1.3.2\user;..\include\os\OS_EXT;..\include\os\OS_LIB;..\include\os\uC-CPU\Source;..\include\os\uC-CPU\ports;..\include\os\uC-LIB\Source;..\include\os\uC-LIB\Ports;..\include\os\uCOS-II\Cfg;..\include\os\uCOS-II\Ports;..\include\os\uCOS-II\Source
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group AD
    ../driver/ad/cs5532/V1.2.0/src/: adjob.c spi_cs5532A.c spi_cs5532B.c
  group Driver
    ../driver/flash/max25xx/V1.2.0/: mx251608d.c
    ../driver/eeprom/f24clxx/V1.2.0/: f24cl64.c
    ../driver/io/V1.2.0/: IO.h dt3102_io.c dt3102_io.h
    ../driver/cbus/i2c/V1.2.0/: I2Cx.c
    ../driver/cbus/spi/V1.2.0/: SPIx.c
    ../driver/keyboard/V1.2.0/: keyboard.c
    ../driver/rtc/pcf8563/V1.2.0/: pcf8563.c
    ../driver/timer/V1.2.0/src/: timer2.c timer5.c timer6.c timer7.c
    ../driver/usart/V1.2.0/src/: printf_init.c usart1.c usart6.c usart_timer.c
    ../driver/wachdog/v1.2.0/: dog_init.c
    ../driver/sound/beep/V1.2.0/: beep_init.c
  group GUI
    ../gui/V1.2.0/Inc/: TextEdit.h GDI.h guiwindows.h Menu.h
    ../gui/V1.2.0/Src/: Windows.c GDI.c Menu.c TextEdit.c
  group LCD
    ../driver/lcd/V1.2.0/src/: LCD.c
    ../driver/lcd/V1.2.0/inc/: LCD.h LCD_cfg.h
  group Net
    ../net/Lwip/lwip_v1.3.2/user/: LWIP_Impl.h LWIP_NetAddr.h eth_init.c netconf.c stm32f4x7_eth.c
    ../net/Lwip/lwip_v1.3.2/port/STM32F4x7/ucos/: sys_arch.c ethernetif.c
    ../net/Lwip/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../net/Lwip/lwip_v1.3.2/src/core/: tcp_out.c udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c
    ../net/Lwip/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../net/Lwip/lwip_v1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../net/Lwip/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
  group OS_Ext
    ../os/V1.2.2/OS_EXT/: task_msg.c task_msg.h
  group OS_Lib
    ../os/V1.2.2/OS_LIB/: includes.h
    ../os/V1.2.2/uC-CPU/Ports/: cpu_c.c cpu_a.asm
    ../os/V1.2.2/uCOS-II/Cfg/: sys_cfg.h
    ../os/V1.2.2/uCOS-II/Custom/Src/: sys_app_hooks.c
    ../os/V1.2.2/uCOS-II/Source/: C2.h sys_core.c sys_flag.c sys_mbox.c sys_mem.c sys_mutex.c sys_q.c sys_sem.c sys_task.c sys_time.c sys_tmr.c
    ../os/V1.2.2/uCOS-II/Ports/: sys_cpu.h sys_cpu_a.asm sys_cpu_c.c sys_dbg.c
  group Stm32F4xx_lib
    ../driver/mcu/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ../driver/mcu/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group Stm32HardCrc
    ../driver/crc/stm32f4xx/V1.2.0/: stm32f4_crc.c stm32f4_crc.h
  group Sys_Lib
    ../driver/model/V1.2.0/: driver.c driver.h stm32f4xx_it.c system_init.c system_init.h
  group Usb
    ../driver/usb/v1.2.0/: Job_USB.c usb_bsp.c usbh_usr.c
    ../driver/usb/v1.2.0/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
    ../driver/usb/v1.2.0/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../driver/usb/v1.2.0/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
  group Fat32
    ../fs/fat_fs/src/: ff.c fattime.c
  group kfifo
    ../../../common/queue/kfifo/V1.0.0/: kfifo.c kfifo.h
